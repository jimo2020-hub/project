# Keil uVision project h5first.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: h5first
  AfterMake: elf2evx --entry __rt_entry --stack 512 -o h5first.evx h5first.axf
  c flags: Optim=1
  group Source Group 1
    ./: h5ses.h h5ses.lib main.c Startup.s
